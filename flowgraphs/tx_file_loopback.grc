options:
  parameters:
    author: gr-dis dev
    description: 'NBFM TX → file loopback. Reads PCM from the bridge ZMQ TX socket, modulates to NBFM IQ at samp_rate centred on center_freq, and writes cf32 to output_file. Play the file back via: gr-dis run --source-file <path>. See examples/config_nbfm_146950.yaml for the matching bridge config.'
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: tx_file_loopback
    output_language: python
    title: NBFM TX File Loopback
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(8e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: SDR LO — must match sdr.center_freq_hz in config.
    value: int(146.7e6)
  states: {}
- name: channel_id
  id: variable
  parameters:
    comment: Must match a tx_enabled channel id in the bridge config.
    value: '"vhf_ch1"'
  states: {}
- name: deviation_hz
  id: variable
  parameters:
    comment: Must match chain_config.deviation_hz in config.
    value: '5000'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: 'IQ output path. Feed back via: gr-dis run --source-file <this path>'
    value: '"/tmp/nbfm_tx_146950.cf32"'
  states: {}
- name: rf_freq_hz
  id: variable
  parameters:
    comment: Channel frequency — must match rf_freq_hz in config.
    value: int(146.95e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must match sdr.sample_rate_hz in config.
    value: int(2.4e6)
  states: {}
- name: zmq_tx_endpoint
  id: variable
  parameters:
    comment: Bridge ZMQ TX bind address — must match bridge.zmq_tx_bind in config.
    value: '"tcp://127.0.0.1:5556"'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    comment: FM modulate 8 kHz audio → complex baseband at quad_rate (48 kHz).
    fh: '-1.0'
    max_dev: deviation_hz
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Generate complex exponential at +(rf_freq_hz - center_freq) to up-shift the NBFM baseband signal to the correct offset in the IQ file.
    freq: rf_freq_hz - center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Writes complex-float-32 IQ. Overwritten on each run (append=False).
      Decode with: gr-dis run --source-file /tmp/nbfm_tx_146950.cf32
    file: output_file
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normalise int16 range to float [-1.0, 1.0].
    const: 1.0/32767.0
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: Multiply NBFM baseband by the complex exponential to place the signal at +(rf_freq_hz - center_freq) offset from DC in the recorded IQ file.
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    comment: Cast int16 PCM to float for FM modulator input.
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Pace output to real time so the IQ file reflects actual timing.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gr_dis_zmq_tx_source_0
  id: gr_dis_zmq_tx_source
  parameters:
    channel_id: channel_id
    comment: |-
      Reads tx_audio.<channel_id> frames from the bridge ZMQ TX socket.
      Outputs int16 PCM at 8 kHz; silence when no TX frames arrive.
    endpoint: zmq_tx_endpoint
    tx_idle_ms: '200'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Spectrum centred on rf_freq_hz. Expect a ±5 kHz FM carrier during TX.
    fc: rf_freq_hz
    fftsize: '1024'
    label: TX IQ
    name: '"TX Output Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Raw int16 PCM from DIS Signal PDUs before NBFM modulation. Flat zero = no PDUs received from bridge. Waveform = audio flowing.
    label1: DIS Audio
    name: '"DIS PDU Audio"'
    size: '1024'
    srate: audio_rate
    type: float
    ymax: '32767'
    ymin: '-32768'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Upsample 48 kHz → samp_rate (50× for 2.4 MHz). Mirrors NBFMTxChain.
    decim: '1'
    fbw: '0.4'
    interp: int(samp_rate / int(48e3))
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_throttle2_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [gr_dis_zmq_tx_source_0, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
