options:
  parameters:
    author: gr-dis dev
    description: Dual-channel WBFM dev capture - publishes to the gr-dis bridge over ZMQ. See flowgraphs/README.md for usage.
    gen_cmake: 'Off'
    generate_options: qt_gui
    id: capture_dev
    output_language: python
    title: gr-dis Dev Capture
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: SDR LO - must match sdr.center_freq_hz in config.
    value: 107.3e6
  states: {}
- name: channel_id_1
  id: variable
  parameters:
    comment: Must match a channel id in config (used as ZMQ topic prefix).
    value: '"fm_ch1"'
  states: {}
- name: channel_id_2
  id: variable
  parameters:
    value: '"fm_ch2"'
  states: {}
- name: gain_db
  id: variable_qtgui_range
  parameters:
    comment: SDR front-end gain. Tune until target station is audible without clipping.
    gui_hint: 2,1,1,1
    label: Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: rf_freq_1
  id: variable_qtgui_range
  parameters:
    comment: Tunes the freq_xlating filter AND triggers a meta ZMQ frame on change, causing the bridge to emit a fresh Transmitter PDU.
    gui_hint: 0,0,1,2
    label: RF 1 Frequency (Hz)
    start: center_freq-(samp_rate/2)
    step: 100e3
    stop: center_freq+(samp_rate/2)
    value: 107.7e6
  states: {}
- name: rf_freq_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RF 2 Frequency (Hz)
    start: center_freq-(samp_rate/2)
    step: 100e3
    stop: center_freq+(samp_rate/2)
    value: 106.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must match sdr.sample_rate_hz in config; 2.4 MHz → wfm_rcv → 48 kHz → rational resampler (÷6) → 8 kHz for DIS Signal PDUs.
    value: '2400000'
  states: {}
- name: squelch_db
  id: variable_qtgui_range
  parameters:
    comment: Power squelch threshold in dBFS. Start around -60; tune to noise floor.
    gui_hint: 2,0,1,1
    label: Squelch (dBFS)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-90'
  states: {}
- name: zmq_endpoint
  id: variable
  parameters:
    comment: Bridge ZMQ bind address - must match bridge.zmq_bind in config.
    value: '"tcp://127.0.0.1:5555"'
  states: {}
- name: analog_pwr_squelch_cc_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    comment: |-
      alpha=1e-3 (tau~21 ms) tracks PTT timing; GR default 1e-4 is too slow for voice.
      ramp=2400 samples = 1 ms @ 2.4 MHz. set_threshold() called live by the squelch slider.
    gate: 'False'
    ramp: '2400'
    threshold: squelch_db
    type: complex
  states: {}
- name: analog_pwr_squelch_cc_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    comment: |-
      alpha=1e-3 (tau~21 ms) tracks PTT timing; GR default 1e-4 is too slow for voice.
      ramp=2400 samples = 1 ms @ 2.4 MHz. set_threshold() called live by the squelch slider.
    gate: 'False'
    ramp: '2400'
    threshold: squelch_db
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate/audio_rate)
    quad_rate: samp_rate
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate/audio_rate)
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: Cast float to int16.
    scale: '1'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    comment: Cast float to int16.
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale float [-1, 1] to int16 range before cast.
    const: '32767'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale float [-1, 1] to int16 range before cast.
    const: '32767'
    type: float
  states: {}
- name: gr_dis_zmq_audio_sink_0
  id: gr_dis_zmq_audio_sink
  parameters:
    comment: ZMQ audio publisher. set_rf_freq_hz() is called live by the RF-freq slider, triggering a meta frame so the bridge emits a fresh Transmitter PDU.
    endpoint: zmq_endpoint
    channel_id: channel_id_1
    chain_name: '"wfm"'
    rf_freq_hz: rf_freq_1
    channel_bw_hz: '200000'
    squelch_rms: '50.0'
    chain_config: '{}'
  states: {}
- name: gr_dis_zmq_audio_sink_0_0
  id: gr_dis_zmq_audio_sink
  parameters:
    endpoint: zmq_endpoint
    channel_id: channel_id_2
    chain_name: '"wfm"'
    rf_freq_hz: rf_freq_2
    channel_bw_hz: '200000'
    squelch_rms: '50.0'
    chain_config: '{}'
  states: {}
- name: freq_xlating_fir_filter_ccc_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rf_freq_1 - center_freq
    comment: |-
      WFM channel select: shifts station to DC, 100 kHz LPF for ±75 kHz FM deviation. decim=1 preserves full 2.4 MHz bandwidth for wfm_rcv quad_rate.
      type=ccf uses real taps from firdes.low_pass (more efficient than ccc).
      set_center_freq() is called live by the RF-freq slider callback.
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 100000, 25000)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_ccc_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rf_freq_2 - center_freq
    comment: |-
      WFM channel select: shifts station to DC, 100 kHz LPF for ±75 kHz FM deviation. decim=1 preserves full 2.4 MHz bandwidth for wfm_rcv quad_rate.
      type=ccf uses real taps from firdes.low_pass (more efficient than ccc).
      set_center_freq() is called live by the RF-freq slider callback.
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 100000, 25000)
    type: ccf
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate/8000)
    fbw: '0.4'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(audio_rate/8000)
    fbw: '0.4'
    interp: '1'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    gain: gain_db
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_cc_0, '0', analog_wfm_rcv_0, '0']
- [analog_pwr_squelch_cc_0_0, '0', analog_wfm_rcv_0_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0_0, '0', audio_sink_0, '1']
- [analog_wfm_rcv_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_float_to_short_0, '0', gr_dis_zmq_audio_sink_0, '0']
- [blocks_float_to_short_0_0, '0', gr_dis_zmq_audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_short_0_0, '0']
- [freq_xlating_fir_filter_ccc_0_0, '0', analog_pwr_squelch_cc_0, '0']
- [freq_xlating_fir_filter_ccc_0_0_0, '0', analog_pwr_squelch_cc_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_ccc_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_ccc_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
